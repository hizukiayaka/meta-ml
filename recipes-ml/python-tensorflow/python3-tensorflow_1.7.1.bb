inherit setuptools3
require python-tensorflow.inc
